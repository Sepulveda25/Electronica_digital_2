#INCLUDE "P16F877A.INC"

DATO_L	EQU	0X20
DATO_H	EQU	0X21
BCD_U	EQU	0X22
BCD_D	EQU	0X23
BCD_C	EQU	0X24
BCD_M	EQU	0X25

	
	ORG 0X00

PRINCIPAL:

	MOVLW	B'00000100'
	MOVWF	DATO_L
	MOVLW	B'00000011'
	MOVWF	DATO_H
CENTENA:
	MOVLW	B'00010111'
	ADDWF	DATO_L,F
	BTFSC	STATUS,C
	INCF	DATO_H,F
	MOVLW	B'11111100'
	ADDWF	DATO_H,F
	BTFSC	STATUS,C
	GOTO	POSITIVO
	GOTO 	NEGATIVO
POSITIVO
	INCF	BCD_M,F
	MOVLW	D'1'
	ADDWF	DATO_L,F
	BTFSC	STATUS,C
	INCF	DATO_H,F
	GOTO	SIGO	
NEGATIVO
	MOVLW	B'11101000'
	ADDWF	DATO_L,F
	BTFSC	STATUS,C
	INCF	DATO_H,F
	MOVLW	B'00000011'
	ADDWF	DATO_H,F

SIGO
	INCF	BCD_C,F
	MOVLW	B'10011011'
	ADDWF	DATO_L;
	BTFSC	STATUS,C
	INCF	DATO_H,F
	MOVLW	0XFF
	ADDWF	DATO_H,F
	BTFSC	STATUS,C
	GOTO	SUMA
	GOTO	CONTINUAR

SUMA
	INCF	DATO_L,F
	GOTO	SIGO

CONTINUAR

	MOVLW	D'101'
	ADDWF	DATO_L,F
	DECF	BCD_C,F
DECENA
	MOVLW	D'10'
	SUBWF	DATO_L,F
	INCF	BCD_D,F
	BTFSC	STATUS,C
	GOTO	DECENA
	MOVLW	D'10'
	ADDWF	DATO_L,F
	DECF	BCD_D,F
UNIDAD
	MOVLW	D'1'
	SUBWF	DATO_L,F
	INCF	BCD_U,F
	BTFSC	STATUS,C
	GOTO	UNIDAD
	DECF	BCD_U,F
	GOTO	$
	END	