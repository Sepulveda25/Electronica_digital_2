#INCLUDE "P16F877A.INC"

DATO	EQU	0X20
BCD_U	EQU	0X21
BCD_D	EQU	0X22
BCD_C	EQU	0X23

	
	ORG 0X00

PRINCIPAL:

	MOVLW	D'100'
	MOVWF	DATO
CENTENA:
	MOVLW	D'100'
	SUBWF	DATO,F
	INCF	BCD_C,F
	BTFSC	STATUS,C	;VERIFICO SI LA CUENTA DIO NEGATIVO
	GOTO	CENTENA
	MOVLW	D'100'		;COMO SE PASO LA RESTA CORRIJO
	ADDWF	DATO,F		; SUMANDO 100 
	DECF	BCD_C,F
DECENA
	MOVLW	D'10'
	SUBWF	DATO,F
	INCF	BCD_D,F
	BTFSC	STATUS,C
	GOTO	DECENA
	MOVLW	D'10'
	ADDWF	DATO,F
	DECF	BCD_D,F
UNIDAD
	MOVLW	D'1'
	SUBWF	DATO,F
	INCF	BCD_U,F
	BTFSC	STATUS,C
	GOTO	UNIDAD
	DECF	BCD_U,F
	GOTO	$
	END	